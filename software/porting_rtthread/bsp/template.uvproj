# Keil uVision project template.uvproj, settings and files
target rtthread (ARM-ADS)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: Project
  AfterMake: fromelf.exe --bin -o ./rtthread.bin #L
  c flags: Optim=3
  c include: ..\User;..\System;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: rtthread-imapx200.sct
