# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Project
  AfterMake: fromelf.exe --bin -o ../Output/@p.bin ../Output/@p.axf
  c flags: Optim=3
  c include: ..\User;..\System;..\Hardware
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\Output\Project.sct
  group User
    ../User/: main.c
  group System
    ../System/: Startup.s
  group Hardware
    ../Hardware/: delay.c led.c
