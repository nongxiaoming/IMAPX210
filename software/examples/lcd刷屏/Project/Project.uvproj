# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: Project
  AfterMake: fromelf.exe --bin -o ../Output/@p.bin ../Output/@p.axf
  c flags: Optim=3
  c include: ..\User;..\System;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: ..\Output\Project.sct
  group User
    ../User/: main.c
  group System
    ../System/: Startup.s
  group Hardware
    ../Hardware/: delay.c led.c uart.c glcd.c clock.c timer.c
